# Keil uVision project project.uvproj, settings and files
target FRDM (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: project
  c flags: Optim=1
  c include: .\CMSIS\ARMCM0plus\Include;.\CMSIS\Include;.\CoOS\portable;.\CoOS\kernel;.\CoOS\Other
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  group Sources
    ./sources/: main.c startup_MKL25Z4.s
  group CMSIS
    ./CMSIS/ARMCM0plus/Source/: system_ARMCM0plus.c
    ./CMSIS/ARMCM0plus/Include/: ARMCM0plus.h system_ARMCM0plus.h
    ./CMSIS/Include/: core_cm0plus.h
  group CoOS
    ./CoOS/portable/Keil/: port.c
    ./CoOS/portable/: arch.c OsArch.h
    ./CoOS/kernel/: coocox.h CoOS.h core.c event.c flag.c hook.c kernelHeap.c mbox.c mm.c mutex.c OsCore.h OsError.h OsEvent.h OsFlag.h OsKernelHeap.h OsMM.h OsMutex.h OsQueue.h OsServiceReq.h OsTask.h OsTime.h OsTimer.h queue.c sem.c serviceReq.c task.c time.c timer.c utility.c utility.h
    ./CoOS/Other/: OsConfig.h
